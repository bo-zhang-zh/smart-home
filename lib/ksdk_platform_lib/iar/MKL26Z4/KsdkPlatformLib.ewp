# IAR project KsdkPlatformLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 NXP MKL26Z128xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL26Z128VLH4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../CMSIS/Include; ../../../../devices; ../../../../platform/drivers; ../../../../platform/drivers/common; ../../../../platform/drivers/uart; ../../../../platform/drivers/uart; ../../../../platform/drivers/tsi; ../../../../platform/drivers/tpm; ../../../../platform/drivers/spi; ../../../../platform/drivers/spi; ../../../../platform/drivers/smc; ../../../../platform/drivers/sim; ../../../../platform/drivers/sai; ../../../../platform/drivers/sai; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rcm; ../../../../platform/drivers/port; ../../../../platform/drivers/pmc; ../../../../platform/drivers/pit; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/lpsci; ../../../../platform/drivers/lpsci; ../../../../platform/drivers/llwu; ../../../../platform/drivers/i2c; ../../../../platform/drivers/gpio; ../../../../platform/drivers/flash; ../../../../platform/drivers/dmamux; ../../../../platform/drivers/dma; ../../../../platform/drivers/dac; ../../../../platform/drivers/cop; ../../../../platform/drivers/common; ../../../../platform/drivers/cmp; ../../../../devices/MKL26Z4; ../../../../platform/drivers/adc16
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL26Z128VLH4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group drivers
    ../../../../platform/drivers/uart/: fsl_uart_dma.h fsl_uart_dma.c fsl_uart.h fsl_uart.c
    ../../../../platform/drivers/tsi/: fsl_tsi_v4.h fsl_tsi_v4.c
    ../../../../platform/drivers/tpm/: fsl_tpm.c fsl_tpm.h
    ../../../../platform/drivers/spi/: fsl_spi_dma.h fsl_spi_dma.c fsl_spi.h fsl_spi.c
    ../../../../platform/drivers/smc/: fsl_smc.h fsl_smc.c
    ../../../../platform/drivers/sim/: fsl_sim.h fsl_sim.c
    ../../../../platform/drivers/sai/: fsl_sai_dma.h fsl_sai_dma.c fsl_sai.h fsl_sai.c
    ../../../../platform/drivers/rtc/: fsl_rtc.c fsl_rtc.h
    ../../../../platform/drivers/rcm/: fsl_rcm.c fsl_rcm.h
    ../../../../platform/drivers/port/: fsl_port.h
    ../../../../platform/drivers/pmc/: fsl_pmc.h fsl_pmc.c
    ../../../../platform/drivers/pit/: fsl_pit.c fsl_pit.h
    ../../../../platform/drivers/lptmr/: fsl_lptmr.c fsl_lptmr.h
    ../../../../platform/drivers/lpsci/: fsl_lpsci_dma.h fsl_lpsci_dma.c fsl_lpsci.h fsl_lpsci.c
    ../../../../platform/drivers/llwu/: fsl_llwu.h fsl_llwu.c
    ../../../../platform/drivers/i2c/: fsl_i2c_dma.c fsl_i2c_dma.h fsl_i2c.h fsl_i2c.c
    ../../../../platform/drivers/gpio/: fsl_gpio.h fsl_gpio.c
    ../../../../platform/drivers/flash/: fsl_flash.c fsl_flash.h
    ../../../../platform/drivers/dmamux/: fsl_dmamux.h fsl_dmamux.c
    ../../../../platform/drivers/dma/: fsl_dma.h fsl_dma.c
    ../../../../platform/drivers/dac/: fsl_dac.c fsl_dac.h
    ../../../../platform/drivers/cop/: fsl_cop.c fsl_cop.h
    ../../../../platform/drivers/cmp/: fsl_cmp.c fsl_cmp.h
    ../../../../devices/MKL26Z4/: fsl_clock.h fsl_clock.c
    ../../../../platform/drivers/adc16/: fsl_adc16.c fsl_adc16.h
