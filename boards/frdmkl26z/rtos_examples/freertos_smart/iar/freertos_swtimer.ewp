# IAR project freertos_swtimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 NXP MKL26Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL26Z128VLH4; FSL_RTOS_FREE_RTOS; FRDM_KL26Z; FREEDOM; ARM_MATH_CM0PLUS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM0; ../../../../../rtos/freertos/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ..; ../../../../../platform/utilities/debug_console; ../../../../../rtos/freertos/Source; ../../..; ../../../../../platform/drivers/lpsci; ../../../../../platform/drivers/flash; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/port; ../../../../../platform/drivers/lptmr; ../../../../../platform/drivers/adc16; ../../../../../platform/drivers/pmc; ../../../../../platform/drivers/sim; ../../../../../devices/MKL26Z4; ../../../../../platform/drivers/common; ../../../../../platform/utilities/debug_console; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/smc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../src/rtos_examples/freertos_swtimer; ..
  ILINK.IlinkOutputFile: freertos_swtimer.out
  ILINK.IlinkIcfFile: ../../../../../devices/MKL26Z4/iar/MKL26Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKL26Z128VLH4; FSL_RTOS_FREE_RTOS; FRDM_KL26Z; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM0; ../../../../../rtos/freertos/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ../../../../src/rtos_examples/freertos_swtimer; ..; ../../../../../platform/utilities/debug_console; ../../../../../rtos/freertos/Source; ../../..; ../../../../../platform/drivers/lpsci; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/port; ../../../../../devices/MKL26Z4; ../../../../../platform/drivers/common; ../../../../../platform/utilities/debug_console; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/smc
  ICCARM.CCOptStrategy: 0
  group board
    ../: app.h bsp.c bsp.h hardware_init.c pin_mux.c pin_mux.h
    ../../../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../platform/drivers/adc16/: fsl_adc16.c fsl_adc16.h
    ../../../../../devices/MKL26Z4/: fsl_clock.c fsl_clock.h
    ../../../../../platform/drivers/common/: fsl_common.c fsl_common.h
    ../../../../../platform/drivers/flash/: fsl_flash.c fsl_flash.h
    ../../../../../platform/drivers/gpio/: fsl_gpio.c fsl_gpio.h
    ../../../../../platform/drivers/lpsci/: fsl_lpsci.c fsl_lpsci.h
    ../../../../../platform/drivers/lptmr/: fsl_lptmr.c fsl_lptmr.h
    ../../../../../platform/drivers/pmc/: fsl_pmc.c fsl_pmc.h
    ../../../../../platform/drivers/port/: fsl_port.h
    ../../../../../platform/drivers/sim/: fsl_sim.c fsl_sim.h
    ../../../../../platform/drivers/smc/: fsl_smc.c fsl_smc.h
    ../../../../../platform/drivers/uart/: fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group source
    ../: analysis.c analysis.h esp8266.c esp8266.h freertos_swtimer.c FreeRTOSConfig.h
    ../../../../../CMSIS/Lib/IAR/: arm_cortexM_math.a
    ../../../../../CMSIS/Include/: arm_math.h
  group startup
    ../../../../../devices/MKL26Z4/iar/: startup_MKL26Z4.s
    ../../../../../devices/MKL26Z4/: system_MKL26Z4.c system_MKL26Z4.h
  group utilities
    ../../../../../platform/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h
